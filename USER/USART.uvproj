# Keil uVision project USART.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: USART +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\SIM900;..\HARDWARE\SIM900GPRS;..\SYSTEM\judgeSerial;..\HARDWARE\PIDControl;..\HARDWARE\Motor;..\HARDWARE\SpeedSense
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SIM900GPRS/: GPRS.C
    ../HARDWARE/PIDControl/: PID.c
    ../HARDWARE/Motor/: motor.c
    ../HARDWARE/SpeedSense/: SpeedSense.c
    ../HARDWARE/SIM900/: SIM900SMS.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c
